# Keil uVision project awtk_damo_ui.uvprojx, settings and files
target awtk_damo_ui flexspi_nor_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.2
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: elcdif_rgb.out
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B, APP_LCDIF_DATA_BUS=kELCDIF_DataBus16Bit, USE_GUI_MAIN,WITH_STB_IMAGE,WITH_BITMAP_RGB565,WITH_STB_FONT,WITH_BITMAP_BGRA,WITH_MINI_FONT,WITH_DYNAMIC_TR
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/io;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/log;../../../../../devices/MIMXRT1052/utilities;../../../../../devices/MIMXRT1052/xip;..\awtk-port;..\..\..\..\..\middleware\awtk;..\..\..\..\..\middleware\awtk\src;..\..\..\..\..\middleware\awtk\3rd;..\..\..\..\..\middleware\awtk\3rd\picasso\src;..\..\..\..\..\middleware\awtk\3rd\picasso\src\gfx;..\..\..\..\..\middleware\awtk\3rd\picasso\src\include;..\..\..\..\..\middleware\awtk\3rd\picasso\include;..\..\..\..\..\middleware\awtk\3rd\picasso\build;..\..\demo_gui
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: elcdif_rgb.c fsl_ft5406_rt.c fsl_ft5406_rt.h
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_elcdif.c fsl_elcdif.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_lpi2c.c fsl_lpi2c.h
  group startup
    ../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group xip
    ../../../../../devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group awtk
    ../../../../../middleware/awtk/src/base/: array.c array.h bitmap.c bitmap.h buffer.c buffer.h button.c button.h candidates.c candidates.h canvas.c canvas.h check_button.c check_button.h color.c color.h dialog.c dialog.h easing.c easing.h edit.c edit.h emitter.c emitter.h enums.c enums.h event_queue.c event_queue.h events.c events.h font.c font.h font_manager.c font_manager.h fs.c fs.h g2d.h glyph_cache.c glyph_cache.h group_box.c group_box.h idle.c idle.h image.c image.h image_loader.c image_loader.h image_manager.c image_manager.h input_engine.c input_engine.h input_method.c input_method.h keyboard.c keyboard.h keys.h label.c label.h layout.c layout.h layout_def.h lcd.c lcd.h locale.c locale.h main_loop.c main_loop.h matrix.c matrix.h mem.c mem.h mutex.h pages.c pages.h platform.h progress_bar.c progress_bar.h rect.c rect.h resource_manager.c resource_manager.h rom_fs.c rom_fs.h slide_view.c slide_view.h slider.c slider.h str.c str.h suggest_words.c suggest_words.h system_info.c system_info.h theme.c theme.h thread.h time.c time.h timer.c timer.h tokenizer.c tokenizer.h types_def.h utf8.c utf8.h utils.c utils.h value.c value.h velocity.c velocity.h vgcanvas.c vgcanvas.h view.c view.h widget.c widget.h widget_animator.c widget_animator.h widget_consts.h widget_factory.c widget_factory.h widget_vtable.c widget_vtable.h window.c window.h window_animator.c window_animator.h window_manager.c window_manager.h wstr.c wstr.h
    ../../../../../middleware/awtk/src/blend/: blend_image_565_565.c blend_image_565_8888.c blend_image_8888_565.c blend_image_8888_8888.c soft_g2d.c soft_g2d.h image_g2d.c image_g2d.h pixel_pack_unpack.h stm32_g2d.c
    ../../../../../middleware/awtk/src/font/: font_bitmap.c font_bitmap.h font_stb.c font_stb.h
    ../../../../../middleware/awtk/src/image_loader/: image_loader_stb.c image_loader_stb.h
    ../../../../../middleware/awtk/src/input_engines/: input_engine_null.c
    ../../../../../middleware/awtk/src/input_methods/: input_method_default.c
    ../../../../../middleware/awtk/src/lcd/: lcd_mem_rgb565.c lcd_mem_rgb565.h
    ../../../../../middleware/awtk/src/main_loop/: main_loop_simple.c main_loop_simple.h
    ../../../../../middleware/awtk/src/misc/: new.cpp
    ../../../../../middleware/awtk/src/ui_loader/: ui_builder.c ui_builder_default.c ui_builder_writer.c ui_loader.c ui_loader_default.c ui_loader_xml.c
    ../../../../../middleware/awtk/src/vgcanvas/: vgcanvas_picasso.cpp
    ../../../../../middleware/awtk/src/widget_animators/: widget_animator_move.c widget_animator_move.h widget_animator_opacity.c widget_animator_opacity.h widget_animator_rotation.c widget_animator_rotation.h widget_animator_scale.c widget_animator_scale.h widget_animator_scroll.c widget_animator_scroll.h widget_animator_value.c widget_animator_value.h
    ../../../../../middleware/awtk/src/window_animators/: window_animator_fb.c
    ../../../../../middleware/awtk/src/xml/: xml_builder.c xml_builder.h xml_parser.c xml_parser.h
    ../../../../../middleware/awtk/src/: tk.c tk.h
  group awtk_port
    ../../../../../middleware/awtk/src/platforms/raw/: mutex_null.c
    ../awtk-port/: main_loop_easyarm_rt1052_raw.c platform.c
  group awtk_3rd_picasso
    ../../../../../middleware/awtk/3rd/picasso/src/: picasso_api.cpp picasso_canvas.cpp picasso_font.cpp picasso_font_api.cpp picasso_gradient.cpp picasso_gradient_api.cpp picasso_image.cpp picasso_mask.cpp picasso_mask_api.cpp picasso_matrix.cpp picasso_matrix_api.cpp picasso_painter.cpp picasso_path.cpp picasso_pattern.cpp picasso_raster_adapter.cpp picasso_rendering_buffer.cpp
    ../../../../../middleware/awtk/3rd/picasso/src/core/: clipper.cpp curve.cpp device.cpp fixedopt.cpp graphic_path.cpp
    ../../../../../middleware/awtk/3rd/picasso/src/gfx/: gfx_blur.cpp gfx_device.cpp gfx_font_adapter_freetype2.cpp gfx_font_adapter_null.cpp gfx_font_adapter_win32.cpp gfx_font_load_freetype2.cpp gfx_gradient_adapter.cpp gfx_image_filters.cpp gfx_raster_adapter.cpp gfx_rendering_buffer.cpp gfx_sqrt_tables.cpp
  group awtk_demo
    ../../../../../middleware/awtk/demos/: demo_main.c resource.c demo_ui_app.c
