# Keil uVision project bootloader_xmodem1k.uvprojx, settings and files
target bootloader_xmodem1k flexspi_nohdr_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: bootloader_xmodem1k.out
  AfterMake: fromelf.exe  --bincombined --bincombined_base=0x0 --output  "$L@L.bin" "$L@L.out"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=0, XIP_BOOT_HEADER_DCD_ENABLE=0, CPU_MIMXRT1052DVL6B
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;..;../../../..;../../../../../../devices/MIMXRT1052/drivers;../../../../../../devices/MIMXRT1052;../../../../../../devices/MIMXRT1052/utilities/io;../../../../../../devices/MIMXRT1052/utilities/str;../../../../../../devices/MIMXRT1052/utilities/log;../../../../../../devices/MIMXRT1052/utilities;../../../../../../devices/MIMXRT1052/xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi__nohdr.scf
  link misc: --remove  
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ../: flexspi_nor.c flexspi_nor.h
  group drivers
    ../../../../../../devices/MIMXRT1052/drivers/: fsl_common.h fsl_common.c fsl_flexspi.c fsl_flexspi.h
