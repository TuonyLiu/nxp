# IAR project emwin_gui_demo.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../CMSIS/Include; ../../../../../devices; ../../..; ../../../../../middleware/emwin/emWin_Config; ../../../../../middleware/emwin/emWin_header; ..; ../../../../../devices/MIMXRT1052/drivers; ../../../../../devices/MIMXRT1052; ../../../../../devices/MIMXRT1052/utilities/io; ../../../../../devices/MIMXRT1052/utilities/str; ../../../../../devices/MIMXRT1052/utilities/log; ../../../../../devices/MIMXRT1052/utilities; ../../../../../devices/MIMXRT1052/xip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: emwin_gui_demo.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../middleware/emwin/emWin_library/IAR/emWin_M4F.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1052DVL6B
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram.icf
  group board
    ../: emwin_support.c emwin_support.h pin_mux.c pin_mux.h
  group board/src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1052/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h
  group emwin/emWin_Config
    ../../../../../middleware/emwin/emWin_Config/: GUIConf.h LCDConf.h
  group emwin/emWin_header
    ../../../../../middleware/emwin/emWin_header/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group source
    ../: emwin_gui_demo.c
  group startup
    ../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group touchpanel
    ../: fsl_ft5406_rt.c fsl_ft5406_rt.h
  group utilities
    ../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
