# IAR project dev_printer_virtual_plain_text_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; _DEBUG=1; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT1052/drivers; ../../../../../../devices/MIMXRT1052; ../../../../../../devices/MIMXRT1052/utilities/io; ../../../../../../devices/MIMXRT1052/utilities/str; ../../../../../../devices/MIMXRT1052/utilities/log; ../../../../../../devices/MIMXRT1052/utilities; ../../../../../../devices/MIMXRT1052/xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: dev_printer_virtual_plain_text_bm.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_IS_SHAREABLE; SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _DEBUG=0; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_IS_SHAREABLE; NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1052DVL6B; USB_STACK_BM
  ICCARM.CCOptLevel: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  group board/src
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1052/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.c usb_osa_bm.h
  group sources
    ../: device_printer.c device_printer.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group startup
    ../../../../../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/printer
    ../: usb_device_printer.c usb_device_printer.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/source
    ../: usb_device_ch9.c usb_device_ch9.h
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
  group usb/device/source/ehci
    ../../../../../../middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h
    ../../../../../../middleware/usb/include/: usb_ehci.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group utilities
    ../../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../../devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
