# Keil uVision project fourWireModeInterrupt.uvprojx, settings and files
target fourWireModeInterrupt debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fourWireModeInterrupt.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1052DVL6B
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\..\..\..\..\..\..\CMSIS\Include;..\..\..\..\..\..\..\..\devices;..;../../../..;../../../../../../../../devices/MIMXRT1052/drivers;../../../../../../../../devices/MIMXRT1052;../../../../../../../../devices/MIMXRT1052/utilities/io;../../../../../../../../devices/MIMXRT1052/utilities/str;../../../../../../../../devices/MIMXRT1052/utilities/log;../../../../../../../../devices/MIMXRT1052/utilities;../../../../../../../../devices/MIMXRT1052/xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
  group source
    ../: fourWireModeInterrupt.c
  group board
    ../: pin_mux.c pin_mux.h
  group board-src
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../../../devices/MIMXRT1052/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_tsc.c fsl_tsc.h
  group startup
    ../../../../../../../../devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../../../../../../../../devices/MIMXRT1052/: system_MIMXRT1052.c system_MIMXRT1052.h
  group utilities
    ../../../../../../../../devices/MIMXRT1052/utilities/io/: fsl_io.c fsl_io.h
    ../../../../../../../../devices/MIMXRT1052/utilities/log/: fsl_log.c fsl_log.h
    ../../../../../../../../devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../../devices/MIMXRT1052/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group xip
    ../../../../../../../../devices/MIMXRT1052/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
target fourWireModeInterrupt flexspi_nor_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fourWireModeInterrupt.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: ..\..\..\..\..\..\..\..\CMSIS\Include;..\..\..\..\..\..\..\..\devices;..;../../../..;..\..\..\..\..\..\..\..\devices\MIMXRT1052\drivers;../../../../../../../../devices/MIMXRT1052;../../../../../../../../devices/MIMXRT1052/utilities/io;../../../../../../../../devices/MIMXRT1052/utilities/str;../../../../../../../../devices/MIMXRT1052/utilities/log;../../../../../../../../devices/MIMXRT1052/utilities;../../../../../../../../devices/MIMXRT1052/xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target fourWireModeInterrupt sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fourWireModeInterrupt.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: ..\..\..\..\..\..\..\..\CMSIS\Include;..\..\..\..\..\..\..\..\devices;..;../../../..;..\..\..\..\..\..\..\..\devices\MIMXRT1052\drivers;..\../../../../../../../devices/MIMXRT1052;..\../../../../../../../devices/MIMXRT1052/utilities/io;..\../../../../../../../devices/MIMXRT1052/utilities/str;..\../../../../../../../devices/MIMXRT1052/utilities/log;..\../../../../../../../devices/MIMXRT1052/utilities;..\../../../../../../../devices/MIMXRT1052/xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
target fourWireModeInterrupt release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fourWireModeInterrupt.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: ..\..\..\..\..\..\..\..\CMSIS\Include;..\..\..\..\..\..\..\devices;..;../../../..;..\../../../../../../../devices/MIMXRT1052/drivers;..\../../../../../../../devices/MIMXRT1052;..\../../../../../../../devices/MIMXRT1052/utilities/io;..\../../../../../../../devices/MIMXRT1052/utilities/str;..\../../../../../../../devices/MIMXRT1052/utilities/log;..\../../../../../../../devices/MIMXRT1052/utilities;..\../../../../../../../devices/MIMXRT1052/xip
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_ram.scf
  link misc: --remove
target fourWireModeInterrupt flexspi_nor_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fourWireModeInterrupt.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: ..\..\..\..\..\..\..\..\CMSIS\Include;..\..\..\..\..\..\..\..\devices;..;../../../..;..\../../../../../../../devices/MIMXRT1052/drivers;..\../../../../../../../devices/MIMXRT1052;..\../../../../../../../devices/MIMXRT1052/utilities/io;..\../../../../../../../devices/MIMXRT1052/utilities/str;..\../../../../../../../devices/MIMXRT1052/utilities/log;..\../../../../../../../devices/MIMXRT1052/utilities;..\../../../../../../../devices/MIMXRT1052/xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: as above
target fourWireModeInterrupt sdram_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.4
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: fourWireModeInterrupt.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --remove
